# Keil uVision project base_practice.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32C031C6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: base_practice
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: bsp.c bsp.h miros.c miros.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
