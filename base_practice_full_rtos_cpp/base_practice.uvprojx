# Keil uVision project base_practice.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32C031C6Ux STMicroelectronics
  pack: Keil.STM32C0xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: base_practice
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c misc: -Wno-declaration-after-statement
  c include: ..\qpc\include;..\qpc\ports\arm-cm\qxk\armclang;..\nucleo-c031c6;..\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: bsp.h shape.h bsp.cpp main.cpp shape.cpp rectangle.cpp rectangle.h circle.cpp circle.h
  group qpc
    ../qpc/src/qf/: qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_time.c qep_hsm.c
    ../qpc/src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
    ../qpc/ports/arm-cm/qxk/armclang/: qxk_port.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
